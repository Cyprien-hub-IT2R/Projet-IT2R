# Keil uVision project ServeurWebIT2R.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ServeurWebIT2R
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: main.c HTTP_Server_CGI.c
    Web/: FichierWeb.c
  group Web
    ./Web/: index.htm adc.cgi home.png IT2R.png led.cgi lcd.cgi Logo_GEii2.png IUT-CACHAN.png RFID.png
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:A/D Converter 1.0.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, Network:CORE 7.0.0, Network:Interface:ETH 7.0.0, Network:Service:Web Server Compact 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:DP83848C 6.1, CMSIS Driver:SPI:SSP 2.5, Device:GPDMA 1.2, Device:GPIO 1.1, Device:PIN 1.0, Device:Startup 1.0.0
